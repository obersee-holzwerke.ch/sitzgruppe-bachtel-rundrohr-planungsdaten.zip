Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-10-19T17:53:25+02:00
Written by: IfcOpenShell 0.9.0.post1
Made in: IfcOpenShell 0.9.0.post1
Authorization: Nobody

# IfcFurniture: Sitzgruppe, Sitzgruppe Bachtel Rundrohr, L 1800 mm
In: Standort
Pset_ManufacturerTypeInformation - Manufacturer: Obersee Holzwerke (Karawan Holz GmbH); ModelLabel: Sitzgruppe Bachtel Rundrohr, L 1800 mm; ModelReference: BACHTEL-RR-1800-STD
OH_Abmessungen - Laenge_mm: 1800; Tiefe_mm: 1540; Tischhoehe_mm: 760; Sitzhoehe_mm: 453; Gewicht_ca_kg: 131; Stuetze: Rundrohr Ø 76,1 × 4 mm; Rollstuhlplatz: no; Material: Lärche, Stahl S235 feuerverzinkt + pulverbeschichtet schwarz matt
